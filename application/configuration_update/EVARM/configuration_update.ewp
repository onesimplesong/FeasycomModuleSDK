# IAR project configuration_update.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072CB ST STM32F072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\include\; ..\..\..\utils; ..\..\..\core; ..\..\..\module; ..\..\..\host\stm32f07x\hal; ..\..\..\host\stm32f07x\st_libs\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\host\stm32f07x\st_libs\CMSIS\Include; ..\..\..\host\stm32f07x\st_libs\CMSIS\Device\ST\STM32F0xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: configuration_update.bin
  ILINK.IlinkOutputFile: configuration_update.out
  ILINK.IlinkIcfFile: STM32F07x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group application
    ../: main.c
  group cmsis
    ../../../host/stm32f07x/st_libs/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f072.s
    ../../../host/stm32f07x/st_libs/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group core
    ../../../core/: at_engine.c common.c
  group hal
    ../../../host/stm32f07x/hal/: hal.c hal_uart.c stm32f0xx_it.c
  group module
    ../../../module/bt826/: bt826.c
  group stm32_libs
    ../../../host/stm32f07x/st_libs/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group utils
    ../../../utils/: utils.c
